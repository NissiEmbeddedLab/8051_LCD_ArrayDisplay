# Keil uVision project 12_LCD_ArrayDisplay.uvproj, settings and files
target Target 1 (MCS-51)
  device: P89V51RD2 NXP
  cpu: IRAM(0-0xFF) IROM(0-0xFFFF) CLOCK(40000000)
  output: 12_LCD_ArrayDisplay +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 12_LCD_ArrayDisplay.c
